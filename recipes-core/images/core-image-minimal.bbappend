IMAGE_INSTALL_append = " hmi-apps"
IMAGE_INSTALL_append += " upgrade u-boot" 
